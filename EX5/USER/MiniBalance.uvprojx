# Keil uVision project MiniBalance.uvprojx, settings and files
target EX5_Ultrasonic_Avoid (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0xC000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: EX5_Ultrasonic_Avoid +hex
  c flags: Optim=3 v6Lang=1 v6LangP=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\USER;..\MiniBalance_COER;..\STM32F10x_FWLib\inc;..\MiniBalance_HARDWARE;..\SYSTEM;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\MiniBalance_HARDWARE\USART3;..\MiniBalance_HARDWARE\OLED;..\MiniBalance_HARDWARE\IIC;..\MiniBalance_HARDWARE\ENCODER;..\MiniBalance_HARDWARE\KEY;..\MiniBalance_HARDWARE\ADC;..\MiniBalance_HARDWARE\MOTOR;..\MiniBalance_HARDWARE\EXTI;..\MiniBalance_HARDWARE\ULTRASONIC;..\MiniBalance\filter;..\MiniBalance_HARDWARE\DMP;..\MiniBalance_HARDWARE\MPU6050;..\MiniBalance\CONTROL;..\MiniBalance\OLED_STATUS
  asm include: as above
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group USER
    ./: stm32f10x_it.c system_stm32f10x.c MiniBalance.c
  group CORE
    ../MiniBalance_COER/: core_cm3.c startup_stm32f10x_hd.s
  group FWLIB
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_adc.c stm32f10x_exti.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group HAREWARE
    ../MiniBalance_HARDWARE/KEY/: key.c
    ../MiniBalance_HARDWARE/ADC/: adc.c
    ../MiniBalance_HARDWARE/MOTOR/: motor.c
    ../MiniBalance_HARDWARE/ENCODER/: encoder.c
    ../MiniBalance_HARDWARE/IIC/: IOI2C.c
    ../MiniBalance_HARDWARE/EXTI/: exti.c
    ../MiniBalance_HARDWARE/USART3/: usart3.c
    ../MiniBalance_HARDWARE/OLED/: oled.c
    ../MiniBalance_HARDWARE/ULTRASONIC/: ultrasonic.c
  group MiniBalance
    ../MiniBalance/CONTROL/: control.c obstacle_guard.c
    ../MiniBalance/filter/: filter.c
    ../MiniBalance_HARDWARE/DMP/: inv_mpu.c inv_mpu_dmp_motion_driver.c
    ../MiniBalance_HARDWARE/MPU6050/: MPU6050.c
    ../MiniBalance/OLED_STATUS/: oled_status.c
software components: CMSIS:CORE 5.6.0
