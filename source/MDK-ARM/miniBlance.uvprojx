# Keil uVision project miniBlance.uvprojx, settings and files
target miniBlance (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: miniBlance +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F103xE
  c include: ../Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;../MiniBalance_HARDWARE/beep;../MiniBalance_HARDWARE/DataScope_DP;../MiniBalance_HARDWARE/DMP;../SYSTEM/delay;../MiniBalance_HARDWARE/ENCODER;../MiniBalance_HARDWARE/IIC;../MiniBalance_HARDWARE/LED;../MiniBalance_HARDWARE/KEY;../MiniBalance_HARDWARE/Lidar;../MiniBalance_HARDWARE/OLED;../MiniBalance_HARDWARE/PSTWO;../MiniBalance/CONTROL;../MiniBalance_HARDWARE/USART3;../MiniBalance/ELE_CCD;../MiniBalance/filter;../MiniBalance_HARDWARE/MPU6050;../MiniBalance/show;../MiniBalance_HARDWARE/Remote;..\MiniBalance_HARDWARE\TrackModule
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group Application/MDK-ARM
    ./: startup_stm32f103xe.s
  group Application/User
    ../Src/: main.c gpio.c adc.c tim.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c
  group Drivers/CMSIS
    ../Src/: system_stm32f1xx.c
  group HAREWARE
    ../MiniBalance_HARDWARE/beep/: beep.c
    ../MiniBalance_HARDWARE/ENCODER/: encoder.c
    ../MiniBalance_HARDWARE/IIC/: IOI2C.c
    ../MiniBalance_HARDWARE/KEY/: key.c
    ../MiniBalance_HARDWARE/LED/: LED.C
    ../MiniBalance_HARDWARE/Lidar/: Lidar.c
    ../MiniBalance_HARDWARE/OLED/: oled.c
    ../MiniBalance_HARDWARE/PSTWO/: pstwo.c
    ../MiniBalance_HARDWARE/USART3/: usart3.c
    ../MiniBalance_HARDWARE/Remote/: capture.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../Src/: sys.c
  group CONTORL
    ../MiniBalance/CONTROL/: control.c
    ../MiniBalance/ELE_CCD/: ELE_CCD.c
    ../MiniBalance/MPU6050/: MPU6050.c
    ../MiniBalance/show/: show.c
    ../MiniBalance_HARDWARE/DMP/: inv_mpu.c inv_mpu_dmp_motion_driver.c
    ../MiniBalance/filter/: filter.c
    ../MiniBalance_HARDWARE/DataScope_DP/: DataScope_DP.C
    ../MiniBalance_HARDWARE/TrackModule/: TrackModule.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c
software components: CMSIS:CORE 4.3.0
